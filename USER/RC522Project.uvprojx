# Keil uVision project RC522Project.uvprojx, settings and files
target RC522Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RC522Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\USER;..\Hardware\Beep;..\Hardware\button;..\Hardware\delay;..\Hardware\ESP8622;..\Hardware\LED;..\Hardware\MFRC522;..\Hardware\OLED;..\Hardware\sys;..\Hardware\usart;..\Hardware\WS2812;..\Hardware\servo;..\Hardware\commonfunction;..\Hardware\rand;..\Hardware\relay;..\AdditionalLib\libqrencode-4.1.1
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ./: stm32f10x_it.c main.c stm32f10x_conf.h test.c
  group DOC
    ../DOC/: ReadMe.txt
  group Hardware
    ../Hardware/Beep/: beep.c
    ../Hardware/MFRC522/: RC522.C
    ../Hardware/delay/: delay.c
    ../Hardware/sys/: sys.c
    ../Hardware/usart/: usart.c
    ../Hardware/OLED/: oled.c
    ../Hardware/ESP8622/: esp8266.c
    ../Hardware/WS2812/: ws2812.c
    ../Hardware/servo/: servo.c
    ../Hardware/commonfunction/: commonfunction.c
    ../Hardware/rand/: rand.c
    ../Hardware/button/: button.c
    ../Hardware/relay/: relay.c
  group QREncode
    ../AdditionalLib/libqrencode-4.1.1/: bitstream.c mask.c mmask.c mqrspec.c qrencode.c qrinput.c qrspec.c rsecc.c split.c
